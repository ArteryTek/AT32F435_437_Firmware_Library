<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project_l0.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>project_l0</project>
                <configuration>at_start_f435</configuration>
            </member>
            <member>
                <project>project_l0</project>
                <configuration>at_start_f437</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
