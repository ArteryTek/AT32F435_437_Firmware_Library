<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bootloader.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>bootloader</project>
                <configuration>at_start_f435</configuration>
            </member>
            <member>
                <project>bootloader</project>
                <configuration>at_start_f437</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
