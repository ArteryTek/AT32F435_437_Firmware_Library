# Keil uVision project app_led3_toggle.uvprojx, settings and files
target at_start_f435 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.5
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f435_app_led3_toggle +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435ZMT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1
  c include: ..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\project\at32f435_437_board;..\inc;..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\middlewares\usbd_class\hid_iap
  memory RVCT4: ROM 0x8006000 size 0x3ea000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c hid_iap_user.c
  group bsp
    ../../../../../project/at32f435_437_board/: at32f435_437_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f435_437_acc.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_usart.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_usb.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group usbd_driver
    ../../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group readme
    ../: readme.txt
target at_start_f437 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.2
  output: at32f437_app_led3_toggle +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1
  c include: as above
  memory RVCT4: ROM 0x8006000 size 0x3ea000
  memory RVCT9: RAM 0x20000000 size 0x60000
