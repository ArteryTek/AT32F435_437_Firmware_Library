# IAR project app_led3_toggle.ewp, settings and files
configuration at_start_f435 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F435ZMT7_v2 ArteryTek -AT32F435ZMT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F435ZMT7; USE_STDPERIPH_DRIVER; AT_START_F435_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f435_437_board; ..\..\..\..\..\middlewares\usbd_class\hid_iap; ..\..\..\..\..\middlewares\usb_drivers\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32f435_app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32F435xM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_f437 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F437ZMT7_v2 ArteryTek -AT32F437ZMT7
  ICCARM.CCDefines: AT32F437ZMT7; USE_STDPERIPH_DRIVER; AT_START_F437_V1
  OBJCOPY.OOCOutputFile: at32f437_app_led3_toggle.bin
  ILINK.IlinkIcfFile: AT32F437xM.icf
  group bsp
    ../../../../../project/at32f435_437_board/: at32f435_437_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f435_437.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f435_437_acc.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_usb.c
  group readme
    ../: readme.txt
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group usbd_drivers
    ../../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c hid_iap_user.c main.c
