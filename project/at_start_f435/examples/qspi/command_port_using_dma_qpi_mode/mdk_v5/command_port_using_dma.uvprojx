# Keil uVision project command_port_using_dma.uvprojx, settings and files
target command_port_using_dma (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F435ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.1
  cpu: IROM(0x08000000,0x3F0000) IRAM(0x20000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: command_port_using_dma +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F435ZMT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32f435_437_board
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_clock.c qspi_cmd_esmt32m.c main.c
  group bsp
    ../../../../../at32f435_437_board/: at32f435_437_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_dma.c at32f435_437_qspi.c at32f435_437_crm.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group readme
    ../: readme.txt
