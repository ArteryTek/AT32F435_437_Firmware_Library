# Keil uVision project otg.uvprojx, settings and files
target otg (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.5
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: otg +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\at_surf_f437_board;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\middlewares\i2c_application_library;..\..\..\..\at_surf_f437_board;..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\middlewares\usbd_class\cdc
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c
  group bsp
    ../../../../at_surf_f437_board/: at_surf_f437_board_delay.c at_surf_f437_board_otg.c at_surf_f437_board_lcd.c at_surf_f437_board_font.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_crm.c at32f435_437_xmc.c at32f435_437_scfg.c at32f435_437_usb.c at32f435_437_acc.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ./: startup_at32f435_437.s
  group readme
    ../: readme.txt
  group usbd_driver
    ../../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../middlewares/usbd_class/cdc/: cdc_class.c cdc_desc.c
