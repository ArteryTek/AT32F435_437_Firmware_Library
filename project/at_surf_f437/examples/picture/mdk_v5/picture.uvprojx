# Keil uVision project picture.uvprojx, settings and files
target picture (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.5
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: picture +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,HAVE_CONFIG_H
  c include: ..\..\..\..\at_surf_f437_board;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\middlewares\i2c_application_library;..\..\..\..\at_surf_f437_board;..\..\..\..\..\middlewares\3rd_party\fatfs\source;..\libmad;..\libmad\msvc++;..\wav;..\flac\include;..\flac\src\libFLAC\include;..\flac\src\libFLAC\include\private;..\ape\apedec;..\tjpgd\src;..\libjpeg\include;..\giflib;..\png;..\libjpeg
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c
  group bsp
    ../../../../../middlewares/i2c_application_library/: i2c_application.c
    ../../../../at_surf_f437_board/: at_surf_f437_board_delay.c at_surf_f437_board_pca9555.c at_surf_f437_board_lcd.c at_surf_f437_board_sd_card.c at_surf_f437_board_diskio.c at_surf_f437_board_font.c at_surf_f437_board_malloc.c at_surf_f437_board_picture.c at_surf_f437_board_picture_tjpgd.c at_surf_f437_board_picture_libjpeg.c at_surf_f437_board_picture_bmp.c at_surf_f437_board_picture_gif.c at_surf_f437_board_picture_png.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_crm.c at32f435_437_i2c.c at32f435_437_dma.c at32f435_437_exint.c at32f435_437_xmc.c at32f435_437_scfg.c at32f435_437_spi.c at32f435_437_sdio.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_adc.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ./: startup_at32f435_437.s
  group fatfs
    ../../../../../middlewares/3rd_party/fatfs/source/: ff.c ffsystem.c ffunicode.c
  group tjpgd
    ../tjpgd/src/: tjpgd.c tjpgd.h tjpgdcnf.h
  group libjpeg
    ../libjpeg/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
    ../libjpeg/: libjpeg_port.c libjpeg_port.h
  group pngle
    ../png/: miniz.c pngle.c
  group readme
    ../: readme.txt
