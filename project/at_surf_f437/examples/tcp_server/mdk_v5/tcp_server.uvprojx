# Keil uVision project tcp_server.uvprojx, settings and files
target tcp_server (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.5
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: telnet +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1
  c include: ..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\at32f435_437_board;..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\port;..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\port\arch;..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include;..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include\lwip;..\..\..\..\..\middlewares\i2c_application_library;..\..\..\..\at_surf_f437_board
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c netconf.c
  group bsp
    ../../../../at_surf_f437_board/: at_surf_f437_board_emac.c at_surf_f437_board_delay.c at_surf_f437_board_pca9555.c at_surf_f437_board_tcp_server.c at_surf_f437_board_lcd.c at_surf_f437_board_font.c
    ../../../../../libraries/drivers/src/: at32f435_437_crm.c
    ../../../../../middlewares/i2c_application_library/: i2c_application.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f435_437_usart.c at32f435_437_emac.c at32f435_437_exint.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_scfg.c at32f435_437_i2c.c at32f435_437_xmc.c at32f435_437_dma.c at32f435_437_tmr.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group lwip
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/netif/: ethernet.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/port/: ethernetif.c sys_arch.c
  group readme
    ../: readme.txt
