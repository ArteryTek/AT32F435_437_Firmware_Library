# Keil uVision project ov5640_capture.uvprojx, settings and files
target ov5640_capture (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.5
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ov5640_capture +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\at32f435_437_board;..\inc;..\hardware\dvp;..\hardware\lcd;..\hardware\ov5640;..\hardware\usart;..\..\..\..\..\..\middlewares\i2c_application_library
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c
    ../../../../../../middlewares/i2c_application_library/: i2c_application.c
  group bsp
    ../../../../../at32f435_437_board/: at32f435_437_board.c
  group hardware
    ../hardware/dvp/: dvp.c
    ../hardware/ov5640/: ov5640.c
    ../hardware/lcd/: xmc_lcd.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_usart.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_xmc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group readme
    ../: readme.txt
