# Keil uVision project extend_sram.uvprojx, settings and files
target set_sram_512k (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.0
  cpu: IROM(0x08000000,0x3F0000) IRAM(0x20000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: extend_sram_512k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1,EXTEND_SRAM=FLASH_EOPB0_SRAM_512K
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32f435_437_board
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c
  group bsp
    ../../../../../at32f435_437_board/: at32f435_437_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_usart.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_misc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ./: startup_at32f435_437_ext_ram.s
  group readme
    ../: readme.txt
target set_sram_448k (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.0
  cpu: as above
  output: extend_sram_448k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1,EXTEND_SRAM=FLASH_EOPB0_SRAM_448K
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
target set_sram_384k (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.0
  cpu: as above
  output: extend_sram_384k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1,EXTEND_SRAM=FLASH_EOPB0_SRAM_384K
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
target set_sram_320k (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.0
  cpu: as above
  output: extend_sram_320k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1,EXTEND_SRAM=FLASH_EOPB0_SRAM_320K
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
target set_sram_256k (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.0
  cpu: as above
  output: extend_sram_256k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1,EXTEND_SRAM=FLASH_EOPB0_SRAM_256K
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
target set_sram_192k (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.0
  cpu: as above
  output: extend_sram_192k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1,EXTEND_SRAM=FLASH_EOPB0_SRAM_192K
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
target set_sram_128k (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.0
  cpu: as above
  output: extend_sram_128k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1,EXTEND_SRAM=FLASH_EOPB0_SRAM_128K
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
