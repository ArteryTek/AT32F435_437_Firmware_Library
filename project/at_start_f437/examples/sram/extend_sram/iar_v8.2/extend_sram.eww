<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\extend_sram.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_128k</configuration>
            </member>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_192k</configuration>
            </member>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_256k</configuration>
            </member>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_320k</configuration>
            </member>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_384k</configuration>
            </member>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_448k</configuration>
            </member>
            <member>
                <project>extend_sram</project>
                <configuration>extend_sram_512k</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
